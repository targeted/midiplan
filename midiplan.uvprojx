# Keil uVision project midiplan.uvprojx, settings and files
target midiplan (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: midiplan
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: C:\ti\TivaWare_C_Series-2.2.0.295;..\evar\devices\tm4c123gxl;..\evar\include;.\tasks;.
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\midiplan.sct
  group .
    ./: main.c
  group driverlib
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.2.0.295/utils/: uartstdio.c
  group evar
    ../evar/src/: evar.c evar_vars.c
    ../evar/devices/tm4c123gxl/: evar_device.c
  group tasks
    ./tasks/: main_task.c input_uart_task.c output_uart_task.c midi_router_task.c
  group midiplan
    ./midiplan/: midiplan.c channels.c controller_values.c midi.c devices.c device.c note_entries.c
  group devices
    ./midiplan/devices/: yamaha_dom30.c yamaha_emt1.c yamaha_rx21.c zoom_rt234.c null_device.c casio_csm1.c gm_device.c kawai_phm.c yamaha_emr1.c kawai_xs1.c yamaha_fb01.c roland_gr09.c korg_pss60.c roland_cm32p.c alesis_sr16.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
